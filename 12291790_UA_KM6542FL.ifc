Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-22T10:42:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 10:42:53 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\e41d791f-4670-44ba-9229-0ff3cc991bc7\4df2bd05-fb02-4b91-98f4-4f3c8768051a\ifc * Database version: 5507 * Database creation date: Wed Mar 22 10:42:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 10:42:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 10:42:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12291790_UA_KM6542FL:26654270_UA_12291790_KM6542FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26654270_UA_12291790_KM6542FL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26654270_UA_12291790_KM6542FL
Type - Pset_ProvisionForVoid - Width: 574 mm; Height: 43 mm; Depth: 504 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - sets with these values: 2
